## Kconfig
```kconfig
config RTL88XXAU
	tristate "Realtek 88XXA USB WiFi"
	depends on USB
	---help---
	  Help message of RTL88XXAU
```
